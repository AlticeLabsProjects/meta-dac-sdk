LIC_FILES_CHKSUM = "file://LICENSE;md5=896c8ffa3d0539d0d980d0217269969d"
SRC_URI:remove = " file://0001-sloci-image-fix-variant-quoting.patch"
SRCREV = "b45be2e049c5c55acb04a5edb017b793d2d9e677"
PV = "v0.1.2+git${SRCPV}"